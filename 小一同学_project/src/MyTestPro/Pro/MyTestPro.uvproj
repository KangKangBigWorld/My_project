# Keil uVision project MyTestPro.uvproj, settings and files
target MyTestPro (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: MyTestPro +hex
  c flags: Optim=1
  c define: STM32F10X_HD_VL
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Arms
    ./: startup_stm32f10x_hd.s
  group Armc
    ../Src/: main.c LED.c LED.h Buzzer.c Buzzer.h IncludeAll.h Game_Snake.h KeyBoard.c KeyBoard.h My_view.c My_view.h Boot_test.c Boot_test.h My_Init.c My_Init.h My_Function.c My_Function.h colock.h colock.c My_Music.c My_Music.h
  group Lib
    ../Src/: System_Init.h System_Init.c Game_Snake.c stm32f10x.h system.h SysTick.c SysTick.h ascii.c ascii.h font.c tftlcd.h tftlcd.c stm32f10x_rcc.h stm32f10x_rcc.c stm32f10x_gpio.h stm32f10x_gpio.c stm32f10x_fsmc.h font.h stm32f10x_fsmc.c Irq.c Irq.h 24cxx.c iic.c spi.c stm32f10x_spi.c touch.c touch.h stm32f10x_spi.h spi.h iic.h 24cxx.h Time_IRQ.c Time_IRQ.h usart1.c usart1.h Rrtc.c Rrtc.h stm32f10x_conf.h stm32f10x_rtc.c stm32f10x_rtc.h dht11.c dht11.h cc936.c diskio.c diskio.h fatfs_app.c fatfs_app.h ff.c ff.h ffconf.h flash.c flash.h integer.h malloc.c malloc.h mp3player.c mp3player.h music.c music.h sd.c sd.h stm32f10x_flash.c stm32f10x_flash.h vs10xx.c vs10xx.h font_show.h font_show.c picture.c picture.h
